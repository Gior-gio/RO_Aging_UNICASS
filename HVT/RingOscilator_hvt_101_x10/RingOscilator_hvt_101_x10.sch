v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 920 -320 920 340 {}
P 4 4 920 -320 1170 -320 1170 340 920 340 {}
N 590 -590 650 -590 {
lab=VDD}
N 590 -550 650 -550 {
lab=VSS}
N 590 -510 650 -510 {
lab=NOT_RO_CON}
N 590 -470 650 -470 {
lab=RO_CON}
N 890 -590 970 -590 {
lab=DUT_FOOTER}
N 890 -550 970 -550 {
lab=DUT_HEADER}
N 890 -510 970 -510 {
lab=DUT_GATE}
N 890 -470 970 -470 {
lab=DRAIN_SENSE}
N 890 -430 970 -430 {
lab=DRAIN_FORCE}
N 590 -430 650 -430 {
lab=A[1]}
N 70 -130 70 -70 {
lab=VDD}
N -70 10 -10 10 {
lab=A[1:97]}
N 70 90 70 130 {
lab=VSS}
N 280 10 320 10 {
lab=A[2:98]}
N 490 -150 490 -100 {
lab=VDD}
N 390 -60 450 -60 {
lab=NOT_RO_CON}
N 490 130 490 190 {
lab=VSS}
N 420 90 450 90 {
lab=RO_CON}
N 390 90 420 90 {
lab=RO_CON}
N 400 10 430 10 {
lab=A[98]}
N 510 10 580 10 {
lab=A[99]}
N 730 -240 730 -200 {
lab=RO_CON}
N 730 -70 730 -30 {
lab=NOT_RO_CON}
N 730 50 730 80 {
lab=RO_CON}
N 730 210 730 250 {
lab=NOT_RO_CON}
N 810 -170 850 -170 {
lab=VDD}
N 810 -90 850 -90 {
lab=VSS}
N 810 -130 850 -130 {
lab=#net1}
N 810 110 850 110 {
lab=VDD}
N 810 150 850 150 {
lab=DUT_GATE}
N 810 190 850 190 {
lab=VSS}
N 620 -130 650 -130 {
lab=A[99]}
N 620 -130 620 150 {
lab=A[99]}
N 620 150 650 150 {
lab=A[99]}
N 580 10 620 10 {
lab=A[99]}
N 1070 -150 1070 -100 {
lab=VDD}
N 970 -60 1030 -60 {
lab=DUT_FOOTER}
N 1070 130 1070 190 {
lab=VSS}
N 1000 90 1030 90 {
lab=DUT_HEADER}
N 970 90 1000 90 {
lab=DUT_HEADER}
N 980 10 1010 10 {
lab=A[99]}
N 1090 10 1160 10 {
lab=A[100]}
N 1200 -130 1200 150 {
lab=A[100]}
N 1200 150 1230 150 {
lab=A[100]}
N 1160 10 1200 10 {
lab=A[100]}
N 850 150 900 150 {
lab=DUT_GATE}
N 1700 -150 1700 -100 {
lab=VDD}
N 1700 100 1700 280 {
lab=VSS}
N 1590 10 1640 10 {
lab=A[100]}
N 1720 10 1790 10 {
lab=A[101]}
N 1600 -60 1660 -60 {
lab=NOT_RO_CON}
N 1940 -240 1940 -200 {
lab=VDD}
N 1940 -70 1940 -30 {
lab=NOT_RO_CON}
N 1940 50 1940 80 {
lab=VDD}
N 1940 210 1940 250 {
lab=NOT_RO_CON}
N 2020 -170 2060 -170 {
lab=VDD}
N 2020 -90 2060 -90 {
lab=VSS}
N 2020 -130 2060 -130 {
lab=#net2}
N 2020 110 2060 110 {
lab=VDD}
N 2020 150 2060 150 {
lab=VSS}
N 2020 190 2060 190 {
lab=VSS}
N 1830 -130 1860 -130 {
lab=A[101]}
N 1830 -130 1830 150 {
lab=A[101]}
N 1830 150 1860 150 {
lab=A[101]}
N 1790 10 1830 10 {
lab=A[101]}
N 2220 -100 2220 -70 {
lab=VDD}
N 2220 90 2220 130 {
lab=VSS}
N 2430 10 2470 10 {
lab=A[1]}
N 2100 10 2140 10 {
lab=A[101]}
N 1230 150 1250 150 {
lab=A[100]}
N 1300 -230 1300 -190 {
lab=RO_CON}
N 1300 -70 1300 -30 {
lab=NOT_RO_CON}
N 1440 -130 1480 -130 {
lab=DRAIN_SENSE}
N 1200 -130 1230 -130 {
lab=A[100]}
N 1480 -130 1550 -130 {
lab=DRAIN_SENSE}
N 1410 -130 1440 -130 {
lab=DRAIN_SENSE}
N 1350 -70 1350 -30 {
lab=VSS}
N 1350 -230 1350 -190 {
lab=VDD}
N 1300 50 1300 90 {
lab=RO_CON}
N 1300 210 1300 250 {
lab=NOT_RO_CON}
N 1410 150 1450 150 {
lab=#net3}
N 1450 150 1520 150 {
lab=#net3}
N 1350 210 1350 250 {
lab=VSS}
N 1350 50 1350 90 {
lab=VDD}
C {iopin.sym} 590 -590 2 0 {name=p81 lab=VDD}
C {iopin.sym} 590 -550 2 0 {name=p82 lab=VSS}
C {iopin.sym} 590 -510 2 0 {name=p83 lab=NOT_RO_CON}
C {iopin.sym} 590 -470 2 0 {name=p84 lab=RO_CON}
C {iopin.sym} 890 -590 2 0 {name=p85 lab=DUT_FOOTER}
C {iopin.sym} 890 -550 2 0 {name=p86 lab=DUT_HEADER}
C {iopin.sym} 890 -510 2 0 {name=p87 lab=DUT_GATE}
C {iopin.sym} 890 -470 2 0 {name=p88 lab=DRAIN_SENSE}
C {iopin.sym} 890 -430 2 0 {name=p89 lab=DRAIN_FORCE}
C {iopin.sym} 590 -430 2 0 {name=p90 lab=A[1]}
C {lab_wire.sym} 70 -90 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 70 120 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -30 10 0 0 {name=p3 sig_type=std_logic lab=A[1:97]}
C {lab_wire.sym} 320 10 0 0 {name=p4 sig_type=std_logic lab=A[2:98]}
C {/foss/designs/RO_Aging_UNICASS/HVT/RingStage/RingStage.sym} 160 10 0 0 {name=x4[1:97]}
C {lab_wire.sym} 490 -150 0 0 {name=p41 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 490 190 0 0 {name=p42 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 420 10 0 0 {name=p48 sig_type=std_logic lab=A[98]}
C {lab_wire.sym} 580 10 0 0 {name=p49 sig_type=std_logic lab=A[99]}
C {lab_wire.sym} 850 -170 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 -90 0 0 {name=p70 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 850 110 0 0 {name=p71 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 850 190 0 0 {name=p72 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -150 0 0 {name=p73 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1070 190 0 0 {name=p74 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1000 10 0 0 {name=p75 sig_type=std_logic lab=A[99]}
C {lab_wire.sym} 1160 10 0 0 {name=p76 sig_type=std_logic lab=A[100]}
C {lab_wire.sym} 450 -60 0 0 {name=p79 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 440 90 0 0 {name=p80 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 730 70 0 0 {name=p91 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 730 -220 0 0 {name=p92 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 730 -30 0 0 {name=p93 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 730 250 0 0 {name=p94 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 900 150 0 0 {name=p95 sig_type=std_logic lab=DUT_GATE}
C {lab_wire.sym} 1020 -60 0 0 {name=p96 sig_type=std_logic lab=DUT_FOOTER}
C {lab_wire.sym} 1020 90 0 0 {name=p97 sig_type=std_logic lab=DUT_HEADER}
C {lab_wire.sym} 1700 280 0 0 {name=p102 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1700 -150 0 0 {name=p103 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1610 10 0 0 {name=p104 sig_type=std_logic lab=A[100]}
C {lab_wire.sym} 1790 10 0 0 {name=p105 sig_type=std_logic lab=A[101]}
C {lab_wire.sym} 1650 -60 0 0 {name=p106 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 2060 -170 0 0 {name=p107 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2060 -90 0 0 {name=p108 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2060 110 0 0 {name=p109 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2060 190 0 0 {name=p110 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1940 -220 0 0 {name=p111 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1940 -30 0 0 {name=p112 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 1940 70 0 0 {name=p113 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1940 250 0 0 {name=p114 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 2060 150 0 0 {name=p115 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2220 -80 0 0 {name=p116 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2220 120 0 0 {name=p117 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2120 10 0 0 {name=p118 sig_type=std_logic lab=A[101]}
C {lab_wire.sym} 2470 10 0 0 {name=p119 sig_type=std_logic lab=A[1]}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 390 -40 0 0 {name=x2}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 390 240 0 0 {name=x5}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 1600 240 0 0 {name=x8}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 1600 -40 0 0 {name=x9}
C {/foss/designs/RO_Aging_UNICASS/HVT/RingStage/RingStage.sym} 2310 10 0 0 {name=x10}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel/rovcel.sym} 470 20 0 0 {name=x11}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel/rovcel.sym} 1050 20 0 0 {name=x12}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel2/rovcel2.sym} 1680 20 0 0 {name=x13}
C {lab_wire.sym} 1350 -220 0 0 {name=p39 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1350 -50 0 0 {name=p40 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1300 -210 0 0 {name=p46 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 1300 -30 0 0 {name=p47 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 1550 -130 0 0 {name=p50 sig_type=std_logic lab=DRAIN_SENSE}
C {/foss/designs/RO_Aging_UNICASS/HVT/load_x10/load_x10.sym} 1320 -130 0 0 {name=x1}
C {lab_wire.sym} 1520 150 0 0 {name=p101 sig_type=std_logic lab=DRAIN_FORCE}
C {lab_wire.sym} 1350 70 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1350 240 0 0 {name=p6 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1300 70 0 0 {name=p7 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 1300 250 0 0 {name=p8 sig_type=std_logic lab=NOT_RO_CON}
C {load_x1.sym} 1320 150 0 0 {name=x3}
