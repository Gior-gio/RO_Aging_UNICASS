v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 900 -320 900 340 {}
P 4 4 900 -320 1150 -320 1150 340 900 340 {}
N 590 -590 650 -590 {
lab=VDD}
N 590 -550 650 -550 {
lab=VSS}
N 590 -510 650 -510 {
lab=NOT_RO_CON}
N 590 -470 650 -470 {
lab=RO_CON}
N 890 -590 970 -590 {
lab=DUT_FOOTER}
N 890 -550 970 -550 {
lab=DUT_HEADER}
N 890 -510 970 -510 {
lab=DUT_GATE}
N 890 -470 970 -470 {
lab=DRAIN_SENSE}
N 890 -430 970 -430 {
lab=DRAIN_FORCE}
N 590 -430 650 -430 {
lab=A[1]}
N 70 -130 70 -70 {
lab=VDD}
N -70 10 -10 10 {
lab=A[1:9]}
N 70 90 70 130 {
lab=VSS}
N 280 10 320 10 {
lab=A[2:10]}
N 470 -150 470 -100 {
lab=VDD}
N 370 -60 430 -60 {
lab=NOT_RO_CON}
N 470 130 470 190 {
lab=VSS}
N 400 90 430 90 {
lab=RO_CON}
N 370 90 400 90 {
lab=RO_CON}
N 380 10 410 10 {
lab=A[10]}
N 490 10 560 10 {
lab=A[11]}
N 710 -240 710 -200 {
lab=RO_CON}
N 710 -70 710 -30 {
lab=NOT_RO_CON}
N 710 50 710 80 {
lab=RO_CON}
N 710 210 710 250 {
lab=NOT_RO_CON}
N 790 -170 830 -170 {
lab=VDD}
N 790 -90 830 -90 {
lab=VSS}
N 790 -130 830 -130 {
lab=#net1}
N 790 110 830 110 {
lab=VDD}
N 790 150 830 150 {
lab=DUT_GATE}
N 790 190 830 190 {
lab=VSS}
N 600 -130 630 -130 {
lab=A[11]}
N 600 -130 600 150 {
lab=A[11]}
N 600 150 630 150 {
lab=A[11]}
N 560 10 600 10 {
lab=A[11]}
N 1050 -150 1050 -100 {
lab=VDD}
N 950 -60 1010 -60 {
lab=DUT_FOOTER}
N 1050 130 1050 190 {
lab=VSS}
N 980 90 1010 90 {
lab=DUT_HEADER}
N 950 90 980 90 {
lab=DUT_HEADER}
N 960 10 990 10 {
lab=A[11]}
N 1070 10 1140 10 {
lab=A[12]}
N 1180 -130 1210 -130 {
lab=A[12]}
N 1180 -130 1180 150 {
lab=A[12]}
N 1180 150 1210 150 {
lab=A[12]}
N 1140 10 1180 10 {
lab=A[12]}
N 830 150 880 150 {
lab=DUT_GATE}
N 1680 -150 1680 -100 {
lab=VDD}
N 1680 100 1680 280 {
lab=VSS}
N 1570 10 1620 10 {
lab=A[12]}
N 1700 10 1770 10 {
lab=A[13]}
N 1550 10 1570 10 {
lab=A[12]}
N 1580 -60 1640 -60 {
lab=NOT_RO_CON}
N 1920 -240 1920 -200 {
lab=VDD}
N 1920 -70 1920 -30 {
lab=NOT_RO_CON}
N 1920 50 1920 80 {
lab=VDD}
N 1920 210 1920 250 {
lab=NOT_RO_CON}
N 2000 -170 2040 -170 {
lab=VDD}
N 2000 -90 2040 -90 {
lab=VSS}
N 2000 -130 2040 -130 {
lab=#net2}
N 2000 110 2040 110 {
lab=VDD}
N 2000 150 2040 150 {
lab=VSS}
N 2000 190 2040 190 {
lab=VSS}
N 1810 -130 1840 -130 {
lab=A[13]}
N 1810 -130 1810 150 {
lab=A[13]}
N 1810 150 1840 150 {
lab=A[13]}
N 1770 10 1810 10 {
lab=A[13]}
N 2200 -100 2200 -70 {
lab=VDD}
N 2200 90 2200 130 {
lab=VSS}
N 2410 10 2450 10 {
lab=A[1]}
N 2080 10 2120 10 {
lab=A[13]}
N 1210 -130 1230 -130 {
lab=A[12]}
N 1210 150 1230 150 {
lab=A[12]}
N 1290 -230 1290 -190 {
lab=RO_CON}
N 1290 -70 1290 -30 {
lab=NOT_RO_CON}
N 1400 -130 1440 -130 {
lab=DRAIN_SENSE}
N 1440 -130 1510 -130 {
lab=DRAIN_SENSE}
N 1340 -70 1340 -30 {
lab=VSS}
N 1340 -230 1340 -190 {
lab=VDD}
N 1230 150 1250 150 {
lab=A[100]}
N 1320 50 1320 90 {
lab=RO_CON}
N 1320 210 1320 250 {
lab=NOT_RO_CON}
N 1430 150 1470 150 {
lab=#net3}
N 1470 150 1540 150 {
lab=#net3}
N 1370 210 1370 250 {
lab=VSS}
N 1370 50 1370 90 {
lab=VDD}
C {iopin.sym} 590 -590 2 0 {name=p81 lab=VDD}
C {iopin.sym} 590 -550 2 0 {name=p82 lab=VSS}
C {iopin.sym} 590 -510 2 0 {name=p83 lab=NOT_RO_CON}
C {iopin.sym} 590 -470 2 0 {name=p84 lab=RO_CON}
C {iopin.sym} 890 -590 2 0 {name=p85 lab=DUT_FOOTER}
C {iopin.sym} 890 -550 2 0 {name=p86 lab=DUT_HEADER}
C {iopin.sym} 890 -510 2 0 {name=p87 lab=DUT_GATE}
C {iopin.sym} 890 -470 2 0 {name=p88 lab=DRAIN_SENSE}
C {iopin.sym} 890 -430 2 0 {name=p89 lab=DRAIN_FORCE}
C {iopin.sym} 590 -430 2 0 {name=p90 lab=A[1]}
C {lab_wire.sym} 70 -90 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 70 120 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -30 10 0 0 {name=p3 sig_type=std_logic lab=A[1:9]}
C {lab_wire.sym} 320 10 0 0 {name=p4 sig_type=std_logic lab=A[2:10]}
C {/foss/designs/RO_Aging_UNICASS/HVT/RingStage/RingStage.sym} 160 10 0 0 {name=x4[1:9]}
C {lab_wire.sym} 470 -150 0 0 {name=p41 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 470 190 0 0 {name=p42 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 400 10 0 0 {name=p48 sig_type=std_logic lab=A[10]}
C {lab_wire.sym} 560 10 0 0 {name=p49 sig_type=std_logic lab=A[11]}
C {lab_wire.sym} 830 -170 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 830 -90 0 0 {name=p70 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 110 0 0 {name=p71 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 830 190 0 0 {name=p72 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1050 -150 0 0 {name=p73 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1050 190 0 0 {name=p74 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 980 10 0 0 {name=p75 sig_type=std_logic lab=A[11]}
C {lab_wire.sym} 1140 10 0 0 {name=p76 sig_type=std_logic lab=A[12]}
C {lab_wire.sym} 430 -60 0 0 {name=p79 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 420 90 0 0 {name=p80 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 710 70 0 0 {name=p91 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 710 -220 0 0 {name=p92 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 710 -30 0 0 {name=p93 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 710 250 0 0 {name=p94 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 880 150 0 0 {name=p95 sig_type=std_logic lab=DUT_GATE}
C {lab_wire.sym} 1000 -60 0 0 {name=p96 sig_type=std_logic lab=DUT_FOOTER}
C {lab_wire.sym} 1000 90 0 0 {name=p97 sig_type=std_logic lab=DUT_HEADER}
C {lab_wire.sym} 1680 280 0 0 {name=p102 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1680 -150 0 0 {name=p103 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1590 10 0 0 {name=p104 sig_type=std_logic lab=A[12]}
C {lab_wire.sym} 1770 10 0 0 {name=p105 sig_type=std_logic lab=A[13]}
C {lab_wire.sym} 1630 -60 0 0 {name=p106 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 2040 -170 0 0 {name=p107 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -90 0 0 {name=p108 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 110 0 0 {name=p109 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 190 0 0 {name=p110 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1920 -220 0 0 {name=p111 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1920 -30 0 0 {name=p112 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 1920 70 0 0 {name=p113 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1920 250 0 0 {name=p114 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 2040 150 0 0 {name=p115 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2200 -80 0 0 {name=p116 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 120 0 0 {name=p117 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2100 10 0 0 {name=p118 sig_type=std_logic lab=A[13]}
C {lab_wire.sym} 2450 10 0 0 {name=p119 sig_type=std_logic lab=A[1]}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 370 -40 0 0 {name=x2}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 370 240 0 0 {name=x5}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 1580 240 0 0 {name=x8}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 1580 -40 0 0 {name=x9}
C {/foss/designs/RO_Aging_UNICASS/HVT/RingStage/RingStage.sym} 2290 10 0 0 {name=x10}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel/rovcel.sym} 450 20 0 0 {name=x11}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel/rovcel.sym} 1030 20 0 0 {name=x12}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel2/rovcel2.sym} 1660 20 0 0 {name=x13}
C {lab_wire.sym} 1340 -210 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1340 -40 0 0 {name=p6 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1290 -210 0 0 {name=p7 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 1290 -30 0 0 {name=p8 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 1510 -130 0 0 {name=p9 sig_type=std_logic lab=DRAIN_SENSE}
C {load_x1.sym} 1310 -130 0 0 {name=x1}
C {lab_wire.sym} 1540 150 0 0 {name=p101 sig_type=std_logic lab=DRAIN_FORCE}
C {lab_wire.sym} 1370 70 0 0 {name=p10 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1370 240 0 0 {name=p11 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1320 70 0 0 {name=p12 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 1320 250 0 0 {name=p13 sig_type=std_logic lab=NOT_RO_CON}
C {load_x1.sym} 1340 150 0 0 {name=x3}
