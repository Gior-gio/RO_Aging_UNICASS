v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 940 -320 940 340 {}
P 4 4 940 -320 1190 -320 1190 340 940 340 {}
N 590 -590 650 -590 {
lab=VDD}
N 590 -550 650 -550 {
lab=VSS}
N 590 -510 650 -510 {
lab=NOT_RO_CON}
N 590 -470 650 -470 {
lab=RO_CON}
N 890 -590 970 -590 {
lab=DUT_FOOTER}
N 890 -550 970 -550 {
lab=DUT_HEADER}
N 890 -510 970 -510 {
lab=DUT_GATE}
N 890 -470 970 -470 {
lab=DRAIN_SENSE}
N 890 -430 970 -430 {
lab=DRAIN_FORCE}
N 590 -430 650 -430 {
lab=A[1]}
N 70 -130 70 -70 {
lab=VDD}
N -70 10 -10 10 {
lab=A[1:97]}
N 70 90 70 130 {
lab=VSS}
N 280 10 320 10 {
lab=A[2:98]}
N 510 -150 510 -100 {
lab=VDD}
N 410 -60 470 -60 {
lab=NOT_RO_CON}
N 510 130 510 190 {
lab=VSS}
N 440 90 470 90 {
lab=RO_CON}
N 410 90 440 90 {
lab=RO_CON}
N 420 10 450 10 {
lab=A[98]}
N 530 10 600 10 {
lab=A[99]}
N 750 -240 750 -200 {
lab=RO_CON}
N 750 -70 750 -30 {
lab=NOT_RO_CON}
N 750 50 750 80 {
lab=RO_CON}
N 750 210 750 250 {
lab=NOT_RO_CON}
N 830 -170 870 -170 {
lab=VDD}
N 830 -90 870 -90 {
lab=VSS}
N 830 -130 870 -130 {
lab=#net1}
N 830 110 870 110 {
lab=VDD}
N 830 150 870 150 {
lab=DUT_GATE}
N 830 190 870 190 {
lab=VSS}
N 640 -130 670 -130 {
lab=A[99]}
N 640 -130 640 150 {
lab=A[99]}
N 640 150 670 150 {
lab=A[99]}
N 600 10 640 10 {
lab=A[99]}
N 1090 -150 1090 -100 {
lab=VDD}
N 990 -60 1050 -60 {
lab=DUT_FOOTER}
N 1090 130 1090 190 {
lab=VSS}
N 1020 90 1050 90 {
lab=DUT_HEADER}
N 990 90 1020 90 {
lab=DUT_HEADER}
N 1000 10 1030 10 {
lab=A[99]}
N 1110 10 1180 10 {
lab=A[100]}
N 1340 -230 1340 -190 {
lab=RO_CON}
N 1340 -70 1340 -30 {
lab=NOT_RO_CON}
N 1450 -130 1490 -130 {
lab=DRAIN_SENSE}
N 1220 -130 1250 -130 {
lab=A[100]}
N 1220 -130 1220 150 {
lab=A[100]}
N 1220 150 1250 150 {
lab=A[100]}
N 1180 10 1220 10 {
lab=A[100]}
N 870 150 920 150 {
lab=DUT_GATE}
N 1490 -130 1560 -130 {
lab=DRAIN_SENSE}
N 1720 -150 1720 -100 {
lab=VDD}
N 1720 100 1720 280 {
lab=VSS}
N 1610 10 1660 10 {
lab=A[100]}
N 1740 10 1810 10 {
lab=A[101]}
N 1590 10 1610 10 {
lab=A[100]}
N 1620 -60 1680 -60 {
lab=NOT_RO_CON}
N 1960 -240 1960 -200 {
lab=VDD}
N 1960 -70 1960 -30 {
lab=NOT_RO_CON}
N 1960 50 1960 80 {
lab=VDD}
N 1960 210 1960 250 {
lab=NOT_RO_CON}
N 2040 -170 2080 -170 {
lab=VDD}
N 2040 -90 2080 -90 {
lab=VSS}
N 2040 -130 2080 -130 {
lab=#net2}
N 2040 110 2080 110 {
lab=VDD}
N 2040 150 2080 150 {
lab=VSS}
N 2040 190 2080 190 {
lab=VSS}
N 1850 -130 1880 -130 {
lab=A[101]}
N 1850 -130 1850 150 {
lab=A[101]}
N 1850 150 1880 150 {
lab=A[101]}
N 1810 10 1850 10 {
lab=A[101]}
N 2240 -100 2240 -70 {
lab=VDD}
N 2240 90 2240 130 {
lab=VSS}
N 2450 10 2490 10 {
lab=A[1]}
N 2120 10 2160 10 {
lab=A[101]}
N 1250 -130 1270 -130 {
lab=A[100]}
N 1390 -70 1390 -30 {
lab=VSS}
N 1390 -230 1390 -190 {
lab=VDD}
N 1250 150 1270 150 {
lab=A[100]}
N 1340 50 1340 90 {
lab=RO_CON}
N 1340 210 1340 250 {
lab=NOT_RO_CON}
N 1450 150 1490 150 {
lab=#net3}
N 1490 150 1560 150 {
lab=#net3}
N 1390 210 1390 250 {
lab=VSS}
N 1390 50 1390 90 {
lab=VDD}
C {iopin.sym} 590 -590 2 0 {name=p81 lab=VDD}
C {iopin.sym} 590 -550 2 0 {name=p82 lab=VSS}
C {iopin.sym} 590 -510 2 0 {name=p83 lab=NOT_RO_CON}
C {iopin.sym} 590 -470 2 0 {name=p84 lab=RO_CON}
C {iopin.sym} 890 -590 2 0 {name=p85 lab=DUT_FOOTER}
C {iopin.sym} 890 -550 2 0 {name=p86 lab=DUT_HEADER}
C {iopin.sym} 890 -510 2 0 {name=p87 lab=DUT_GATE}
C {iopin.sym} 890 -470 2 0 {name=p88 lab=DRAIN_SENSE}
C {iopin.sym} 890 -430 2 0 {name=p89 lab=DRAIN_FORCE}
C {iopin.sym} 590 -430 2 0 {name=p90 lab=A[1]}
C {lab_wire.sym} 70 -90 0 0 {name=p1 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 70 120 0 0 {name=p2 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -30 10 0 0 {name=p3 sig_type=std_logic lab=A[1:97]}
C {lab_wire.sym} 320 10 0 0 {name=p4 sig_type=std_logic lab=A[2:98]}
C {/foss/designs/RO_Aging_UNICASS/HVT/RingStage/RingStage.sym} 160 10 0 0 {name=x4[1:97]}
C {lab_wire.sym} 510 -150 0 0 {name=p41 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 510 190 0 0 {name=p42 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 440 10 0 0 {name=p48 sig_type=std_logic lab=A[98]}
C {lab_wire.sym} 600 10 0 0 {name=p49 sig_type=std_logic lab=A[99]}
C {lab_wire.sym} 870 -170 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 870 -90 0 0 {name=p70 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 870 110 0 0 {name=p71 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 870 190 0 0 {name=p72 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1090 -150 0 0 {name=p73 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1090 190 0 0 {name=p74 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1020 10 0 0 {name=p75 sig_type=std_logic lab=A[99]}
C {lab_wire.sym} 1180 10 0 0 {name=p76 sig_type=std_logic lab=A[100]}
C {lab_wire.sym} 1390 -210 0 0 {name=p77 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1390 -40 0 0 {name=p78 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 470 -60 0 0 {name=p79 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 460 90 0 0 {name=p80 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 750 70 0 0 {name=p91 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 750 -220 0 0 {name=p92 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 750 -30 0 0 {name=p93 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 750 250 0 0 {name=p94 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 920 150 0 0 {name=p95 sig_type=std_logic lab=DUT_GATE}
C {lab_wire.sym} 1040 -60 0 0 {name=p96 sig_type=std_logic lab=DUT_FOOTER}
C {lab_wire.sym} 1040 90 0 0 {name=p97 sig_type=std_logic lab=DUT_HEADER}
C {lab_wire.sym} 1340 -210 0 0 {name=p98 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 1340 -30 0 0 {name=p99 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 1560 -130 0 0 {name=p100 sig_type=std_logic lab=DRAIN_SENSE}
C {lab_wire.sym} 1560 150 0 0 {name=p101 sig_type=std_logic lab=DRAIN_FORCE}
C {lab_wire.sym} 1720 280 0 0 {name=p102 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1720 -150 0 0 {name=p103 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1630 10 0 0 {name=p104 sig_type=std_logic lab=A[100]}
C {lab_wire.sym} 1810 10 0 0 {name=p105 sig_type=std_logic lab=A[101]}
C {lab_wire.sym} 1670 -60 0 0 {name=p106 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 2080 -170 0 0 {name=p107 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2080 -90 0 0 {name=p108 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2080 110 0 0 {name=p109 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2080 190 0 0 {name=p110 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1960 -220 0 0 {name=p111 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1960 -30 0 0 {name=p112 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 1960 70 0 0 {name=p113 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1960 250 0 0 {name=p114 sig_type=std_logic lab=NOT_RO_CON}
C {lab_wire.sym} 2080 150 0 0 {name=p115 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2240 -80 0 0 {name=p116 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2240 120 0 0 {name=p117 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2140 10 0 0 {name=p118 sig_type=std_logic lab=A[101]}
C {lab_wire.sym} 2490 10 0 0 {name=p119 sig_type=std_logic lab=A[1]}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 410 -40 0 0 {name=x2}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 410 240 0 0 {name=x5}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 1620 240 0 0 {name=x8}
C {/foss/designs/RO_Aging_UNICASS/HVT/passGate_hvt/passGate_hvt.sym} 1620 -40 0 0 {name=x9}
C {/foss/designs/RO_Aging_UNICASS/HVT/RingStage/RingStage.sym} 2330 10 0 0 {name=x10}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel/rovcel.sym} 490 20 0 0 {name=x11}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel/rovcel.sym} 1070 20 0 0 {name=x12}
C {/foss/designs/RO_Aging_UNICASS/HVT/rovcel2/rovcel2.sym} 1700 20 0 0 {name=x13}
C {load_x1.sym} 1360 -130 0 0 {name=x1}
C {lab_wire.sym} 1390 70 0 0 {name=p5 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1390 240 0 0 {name=p6 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1340 70 0 0 {name=p7 sig_type=std_logic lab=RO_CON}
C {lab_wire.sym} 1340 250 0 0 {name=p8 sig_type=std_logic lab=NOT_RO_CON}
C {load_x1.sym} 1360 150 0 0 {name=x3}
